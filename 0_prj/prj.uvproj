# Keil uVision project prj.uvproj, settings and files
target prj (MCS-51)
  device: AiP8F3264 AiP MCU
  cpu: IRAM(0 - 0xFF) XRAM(0-0x7FF) IROM(0-0xFFFF) CLOCK(16000000)
  output: prj
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\1_bsp;..\2_hal;..\3_app;..\4_user
  link misc: REMOVEUNUSED
  group bsp
    ../1_bsp/: typedef.h bsp_STARTUP.A51 bsp_sfr.h bsp_adc.c bsp_crc_sum.c bsp_flash_eep.c bsp_gpio.c bsp_spi.c bsp_timer.c bsp_uart.c bsp_wdt_wt_lvr_lvd.c bsp_uart_ringbuf.c IcoreTKDebug.c TouchKeyCTC_V1.9.c IcoreTouchKeyLib_Small_V1.9.LIB
  group user
    ../4_user/: main.c user_include.h
